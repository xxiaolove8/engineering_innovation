/******************************************************************************************************
========================================名称：综合例程 机械臂==========================================    
========================================所属：杭州众灵科技有限公司=====================================
========================================时间：2016年8月04日============================================   
========================================编写：ZL-Tech==================================================                                   
========================================功能简介：PS2手柄控制，蓝牙控制================================                     
蓝牙串口控制
    改程序将舵机执行封装为指令：如#0P2000T1000!形式。
    0表示舵机序号，即0号舵机；
    2000表示pwm1为2000（范围500~2500）；
    1000表示0号舵机要从原来位置执行到目标位置需要花费1000ms。
    比如，我想要2号舵机，用500ms的时间，执行到1300这个位置。
    命令为：#2P1300T500!
    舵机的周期0.5ms-2.5ms。
    0.5对应0度，2.5对应180度。比如达到90度，则舵机周期为1.5ms，pwm1值对应为1500。  
关键：
    1、机械臂舵机的控制原理
    2、舵机执行时间的处理
    3、串口对命令的解析与保存
功能：
    1、功能1：手柄操控
        解释：手柄遥控控制车子前后左右
              预留手柄按键控制机械臂关节
    2、功能2：手机APP控制
        解释：雷同手柄控制
    3、功能3：一键超声波避障
        解释：手柄绿灯模式下，某按键一键实现避障功能
    4、功能4：一键自动寻迹+避障
        解释：手柄绿灯模式下，某按键一键实现自动寻迹功能，同时遇到障碍物停止

        
********************************************************************************************/
//#include <MsTimer2.h>             //定时器库的 头文件
#include <PS2X_lib.h>              //声明PS2手柄库
#include <Servo.h>               //声明舵机库
#include <SoftwareSerial.h>    //包含软串口头文件，硬串口通信文件库系统自带   String uart1_receive_buf = "";
String uart1_receive_buf = "";   //声明一个字符串数组
char cmd_return[101];
/*******************************一些宏定义****************************************/
#define DJ_NUM  6                //宏定义伺服舵机的个数  
Servo myservo[DJ_NUM];           //创建舵机伺服对象数组
PS2X ps2x;                       //创建PS2控制器类
SoftwareSerial mySerial(A4,A5); //创建一个软串口的类，模拟引脚4,5分别代表 RX, TX引脚
/******************************************************************
 宏定义PS2手柄引脚，用有有意义的字符代表相应是引脚，便于使用
******************************************************************/
#define PS2_DAT      8     
#define PS2_CMD      9 
#define PS2_ATT      2
#define PS2_CLK      4
/*电机驱动引脚*/
#define IN1 3        //定义IN1引脚
#define IN2 5        //定义IN2引脚
#define IN3 11        //定义IN3引脚
#define IN4 6       //定义IN4引脚

#define beep_on() {digitalWrite(BEEP_PIN, LOW);}
#define beep_off() {digitalWrite(BEEP_PIN, HIGH);} 
/**********宏定义区**********/

#define WIFI 0  //wifi use

#define  NLED_MS_BETWEEN        1000
#define  PS2_MS_BETWEEN         50
#define  WARNING_MS_BETWEEN     1000
#define  WARNING_VOLTAGE_VALUE  6
#define  DUOJI_MS_BETWEEN       20
#define  BEEP_PIN   12             //定义蜂鸣器引脚D12
#define  NLED_PIN   13             //定义呼吸灯引脚D13

int PS_LY,PS_LX;                         //PS2手柄左摇杆Y轴数据
int PS_RY,PS_RX;                         //PS2手柄右摇杆Y轴数据
int temp;
int car_left_pwm1; 
int car_right_pwm1;
int car_left_pwm1_bak; 
int car_right_pwm1_bak;
bool car_left_dir;
bool car_right_dir;
bool detach_flag = 0;
byte type = 0;
unsigned int delay_ms =1500;
unsigned int time_max = 0;
unsigned int duoji_index, i;       //声明舵机变量 （舵机号）
byte duoji_pin[DJ_NUM] = {10, A2, A3, A0, A1, 7};//定义一个数组，存储引脚数字
/***********************************结构体变量声明*******************************************/
typedef struct {//舵机结构体变量声明
    unsigned int aim = 1500;   //舵机目标值 
    float cur = 1500;          //舵机当前值
    unsigned  int time1 = 1500;//舵机执行时间
    float inc= 0.00;          //舵机值增量，以20ms为周期
}duoji_t;


static unsigned long last_time = 0;
duoji_t duoji_doing[DJ_NUM];           //用结构体变量声明一个舵机变量数组
byte duoji_doing_flag[DJ_NUM] = {0}; 
void handle_nled();
void handle_duoji();              //声明舵机处理函数
void handle_uart1();              //声明串口处理函数
void handle_ps2();                //声明PS2处理函数
void handle_warning(void);        //声明低压报警函数
void dida(u8 times, u8 frequency);//声明滴答函数
void handle_auto_group(void);      
void setup() {
    pinMode(BEEP_PIN, OUTPUT);
    pinMode(NLED_PIN, OUTPUT);
    digitalWrite(BEEP_PIN, HIGH );
    Serial.begin(115200); 
    ps2x.config_gamepad(PS2_CLK, PS2_CMD, PS2_ATT, PS2_DAT, true, true);//配置PS2手柄

    /*
    type = ps2x.readType();//返回PS2类型
     switch(type) {
       case 0:
        Serial.println("Unknown Controller type");
       break;
       case 1:
        Serial.println("DualShock Controller Found");
       break;
       case 2:
         Serial.println("GuitarHero Controller Found");
       break;
     }*/
    
    motor_drive(0, 0, 0, 0);
    
    for(byte i = 0; i < DJ_NUM; i++) {//循环使相应的舵机伺服对象连接到对应的引脚
        myservo[i].attach(duoji_pin[i]);
       // myservo[1].detach(); 
    }
    for(byte i = 0; i < DJ_NUM; i++) {
        myservo[i].writeMicroseconds( duoji_doing[i].aim);//循环写入初始pwm1目标值 
    }
#if WIFI
    dida(1, 50);
    //启动 50S 等待WIFI
    for(i=0;i<250;i++) {
        digitalWrite(NLED_PIN, 0);
        delay(100);
        digitalWrite(NLED_PIN, 1);
        delay(100);
    }
#endif
    dida(3, 50);

    for(byte i = 0; i < DJ_NUM; i++) {//循环使相应的舵机伺服对象连接到对应的引脚
        myservo[i].detach();
        duoji_doing_flag[i] = 1;
    }

    mySerial.begin(9600);         //设置软串口波特率
    mySerial.println("SoftSerial Init OK");
}

void loop() {
    handle_nled();  //信号灯处理
    handle_uart1(); //串口1 处理
    handle_duoji(); //舵机处理
    handle_ps2();   //手柄处理
    handle_duoji_r();//舵机恢复处理
    //handle_warning();//低压报警处理
}






